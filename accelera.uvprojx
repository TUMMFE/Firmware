# Keil uVision project accelera.uvprojx, settings and files
target Accelera (6190000::V6.19::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: aceclera
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: HSE_VALUE=8000000
  c include: .\Source\inc;.\Middleware\ST\STM32_USB_Device_Library\Core\Inc;.\Middleware\ST\STM32_USB_Device_Library\Class\CDC\Inc;.\USB_DEVICE\App;.\USB_DEVICE\Target;.\Middleware\LWRB\inc;.\SGLib\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Main
    ./Source/src/: adxl355.c main.c sound.c stm32f4xx_it.c
  group USB Device
    ./USB_DEVICE/Target/: usbd_conf.c
    ./USB_DEVICE/App/: usb_device.c usbd_cdc_if.c usbd_desc.c
  group Middleware
    ./Middleware/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ./Middleware/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ./Middleware/LWRB/src/: lwrb.c
  group SG Lib
    ./SGLib/src/: sg_io.c sg_rcc.c
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Device:STM32Cube Framework:Classic 1.7.9, Device:STM32Cube HAL:Common 1.7.9, Device:STM32Cube HAL:Cortex 1.7.9, Device:STM32Cube HAL:DMA 1.7.9, Device:STM32Cube HAL:EXTI 1.7.9, Device:STM32Cube HAL:Flash 1.7.9, Device:STM32Cube HAL:GPIO 1.7.9, Device:STM32Cube HAL:PCD 1.7.9, Device:STM32Cube HAL:PWR 1.7.9, Device:STM32Cube HAL:RCC 1.7.9, Device:STM32Cube HAL:SPI 1.7.9, Device:STM32Cube HAL:TIM 1.7.9, Device:Startup 2.6.3
